# IAR project CS1110.ewp, settings and files
configuration Build (ARM, debug)
  General.OGChipSelectEditMenu: GD32F303xC GD GD32F303xC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; _ANYID_GD32_; _ANYID_HSE12P00_; _ANYID_CS1110_; _ANYID_BOOT_GD32_
  ICCARM.CCIncludePath2: ..\; ..\inc; E:\AnyID\AnyID_Embedded\V1.1.0\STM32_lib_V3.3\startup; E:\AnyID\AnyID_Embedded\V1.1.0\STM32_lib_V3.3\inc; E:\AnyID\AnyID_Embedded\V1.1.0\AnyID_lib_V1.1.0\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CS1110.hex
  ILINK.IlinkOutputFile: CS1110.out
  ILINK.IlinkIcfFile: GD32F303xC.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../AnyID_Embedded/V1.1.0/STM32_lib_V3.3/startup/: system_stm32f10x.c
  group EWARMv5
    ../../../../AnyID_Embedded/V1.1.0/STM32_lib_V3.3/startup/: startup_stm32f10x_hd.s
  group Main
    ../: main.c stm32f10x_conf.h stm32f10x_it.c
  group StdPeriph_Driver
    ../../../../AnyID_Embedded/V1.1.0/STM32_lib_V3.3/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group User
    ../src/: AnyID_CS1110_DishLcm.c AnyID_CS1110_DishLcm_HL.c AnyID_CS1110_Flash_HL.c AnyID_CS1110_FlashM25.c AnyID_CS1110_FRam.c AnyID_CS1110_FRam_HL.c Anyid_CS1110_Key.c Anyid_Cs1110_Key_HL.c Anyid_CS1110_Reader.c Anyid_Cs1110_Rfid.c Anyid_Cs1110_Rfid_HL.c AnyID_CS1110_RTC.c Anyid_Cs1110_Sound.c Anyid_Cs1110_Sound_HL.c AnyID_CS1110_ST25R391x_HL.c AnyID_CS1110_SysCfg.c AnyID_CS1110_SysTick_HL.c AnyID_CS1110_Uart.c AnyID_CS1110_Uart_HL.c Anyid_Cs1110_Wight.c Anyid_Cs1110_Wight_HL.c AnyID_FlashM25.c AnyID_FRam.c AnyID_Uart_Receive.c
    ../../../../AnyID_Embedded/V1.1.0/AnyID_lib_V1.1.0/src/: AnyID_ST25R391x.c AnyID_ST25R391x_ISO15693.c AnyID_Stdlib.c
